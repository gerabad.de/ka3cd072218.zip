Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2017-09-01T15:39:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 01 15:39:28 2017 * Host: Polantis_Production_E * Database: C:\Users\ADMINI~1\AppData\Local\Temp\{3344E728-0079-4D94-813C-A965977B6690}\ifc * Database version: 5507 * Database creation date: Fri Sep 01 15:39:26 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Sep 01 15:39:26 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Sep 01 15:39:26 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: CENTRO UNTERBAUWASCHTISCH 3059 380x610, KDW010085:CENTRO UNTERBAUWASCHTISCH 3059 380x610:126087
In: Level 1
Material: Acier, chromé, Kaldewei
Pset_ManufacturerTypeInformation - Manufacturer: Kaldewei
Pset_DistributionFlowElementCommon - Reference: CENTRO UNTERBAUWASCHTISCH 3059 380x610
